<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>bool_write_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>'No'</value></param>
<param><key>label1</key><value>'Yes'</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>comment</key><value>Ben's Stack 13  -&gt;  int(400.000E6)+0
Grav3                     -&gt;  int(400.000E6)-20000</value></param>
<param><key>value</key><value>int(400.000E6)-20000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>qt_gain</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>s0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>start band</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>(samp_rate/-2.0)+1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>(samp_rate/2.0)-1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>s1</value></param>
<param><key>value</key><value>100</value></param>
<param><key>label</key><value>stop band</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>(samp_rate/-2.0)+1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>(samp_rate/2.0)-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(100E3)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1E6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>1E6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>bool_write_file</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>1+s1</value></param>
<param><key>low_cutoff_freq</key><value>0+s0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import struct

def complex_to_raw(n):

    s1 = struct.pack('%df' % 1, np.real(n))
    s2 = struct.pack('%df' % 1, np.imag(n))

    return s1 + s2

class blk(gr.sync_block):
    def __init__(self, filename_base=''):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Optional File Sync',
            in_sig=[np.complex64,np.complex64],
            out_sig=[np.complex64]
        )
        self.enable = False
        self.state = 0
        self.base = filename_base
        self.tail = '.raw'
        self.files_written = 0
        self.write_name = ''
        self.samples_written = 0

    def get_fname(self):
        if self.base is '':
            raise ValueError('\n\n\n    Optional File Sync filename must not be empty!!!!!\n\n\n')
        name = self.base + '_' + str(self.files_written) + self.tail
        self.files_written += 1
        return name
        

    def work(self, input_items, output_items):


        if len(input_items[1]) and (np.real(input_items[1][0]) &gt; 0.1):
            next_enable = True
        else:
            next_enable = False

        if not self.enable and next_enable:
            name = self.get_fname()
            self.write_name = name
            print 'opening ' + self.write_name
            self.dumpfile = open(self.write_name, 'w')

        if self.enable and not next_enable:
            print 'closing ' + self.write_name + ', wrote ' + str(self.samples_written) + ' samples'
            self.dumpfile.close()
            self.write_name = ''


        self.enable = next_enable

        if self.enable:
            for s in input_items[0]:
                self.dumpfile.write(complex_to_raw(s))
            self.samples_written += len(input_items[0]) 

                # print np.real(input_items[1][0])
        # print len(input_items[1])
        return len(input_items[0])

</value></param>
<param><key>comment</key><value>Set the filename to an ABSOLUTE
path without .raw on the end,
this block will append _0.raw _1.raw etc</value></param>
<param><key>filename_base</key><value>'/home/sigsta4/grc/data/grav2_stack10_400'</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>16383</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate/2</value></param>
<param><key>center_freq0</key><value>center_freq+variable_qtgui_range_0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>qt_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>maxoutbuf</key><value>0x8000</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>minoutbuf</key><value>0x8000</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
